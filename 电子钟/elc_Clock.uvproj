# Keil uVision project elc_Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: elc_Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: KeyBoard.c LCD1602.c Main.c DS1302.c
